# IAR project Wireless.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\; ..\STM8L15x_StdPeriph_Driver\inc; ..\STM8L15x_StdPeriph_Driver\src; ..\Console; ..\CC1101; ..\Sensors
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Wireless.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../CC1101/: CC1101.c
  group Sensor
    ../Sensors/: ADC.c BH1750.c i2c.c SI7021.c
  group StdPeriph_Driver
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_usart.c
  group User
    ../Console/: Console.c tlv.c
    ../user/: main.c
