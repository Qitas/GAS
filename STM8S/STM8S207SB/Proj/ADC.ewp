# IAR project ADC.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207SB STM8S207SB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\user; $TOOLKIT_DIR$\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC.hex
  ILINK.IlinkOutputFile: ADC.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group USR
    ../user/: adc.c adc.h clk_conf.c clk_conf.h led.c led.h main.c stm8s_interruput.c type_def.h uart.c uart.h
